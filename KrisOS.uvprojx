# Keil uVision project KrisOS.uvprojx, settings and files
target Demo2 (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: KrisOS
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c misc: --diag_suppress 815
  c include: .\src\Common;.\src\HAL & Drivers;.\src\Kernel;.\src\User Code
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Kernel
    ./src/Kernel/: heap.c os.c scheduler.c mutex.c semaphore.c os_tasks.c
  group HAL & Drivers
    ./src/HAL & Drivers/: nvic.c special_reg_access.s time.c uart.c startup.s
  group User Code
    ./src/User Code/: nokia5110.c retarget.c light_sensor.c thermometer.c nokia5110_backlight.c demo3.c
target Demo1 (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: as above
  output: KrisOS
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c misc: --diag_suppress 815
  c include: as above
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
