# Keil uVision project KrisRTOS.uvprojx, settings and files
target Main Target (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: KrisRTOS
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group KrisEmbedOS
    ./: heap.c svc.c os.c fifo.c
  group OSTest
    ./: main.c
  group HAL
    ./: uart.c time.c special_reg_access.s startup.s retarget.c nvic.c
